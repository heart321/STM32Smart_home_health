# Keil uVision project Smart_home.uvprojx, settings and files
target Smart_home (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x20013FFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: Smart_home +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c include: ../Core/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;../BSP/AHT20;../BSP/Airquality;../BSP/Buzzer;../BSP/DRV8833;../BSP/GY906;../BSP/LED;../BSP/LM2904;../BSP/MAX30102;../BSP/NetWork;../BSP/OLED;../BSP/PM2.5;../BSP/Relay;../BSP/SG90;../BSP/USART;../BSP/WUHUA;../Task/include;../Middlewares/MQTT;../BSP/IWDOG
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x14000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c iwdg.c tim.c usart.c stm32f2xx_it.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c
  group Application/Task
    ../Task/: app_aht20_task.c app_air_task.c app_gy906_task.c app_lm2904_task.c app_max30102_task.c app_mqttRev_task.c app_mqttSend_task.c
  group Drivers/Bsp
    ../BSP/AHT20/: bsp_aht20_driver.c
    ../BSP/Airquality/: bsp_airquality_driver.c
    ../BSP/Buzzer/: bsp_buzzer_driver.c
    ../BSP/DRV8833/: bsp_drv8833_driver.c
    ../BSP/GY906/: bsp_gy906_driver.c
    ../BSP/LED/: bsp_led_driver.c
    ../BSP/LM2904/: bsp_lm2904_driver.c
    ../BSP/MAX30102/: bsp_max30102_driver.c
    ../BSP/NetWork/: bsp_esp8266_driver.c
    ../BSP/OLED/: bsp_oled_driver.c oledfont.c
    ../BSP/PM2.5/: bsp_pm2.5_driver.c
    ../BSP/Relay/: bsp_relay_driver.c
    ../BSP/SG90/: bsp_sg90_driver.c
    ../BSP/USART/: bsp_usart_driver.c
    ../BSP/WUHUA/: bsp_wuhua_driver.c
    ../BSP/IWDOG/: bsp_iwdog_driver.c
  group Middlewares/MQTT
    ../Middlewares/MQTT/: cJSON.c Cloud.c MqttKit.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_i2c.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
