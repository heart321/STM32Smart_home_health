# Keil uVision project Smart_home.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F205RET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c include: ..\Libraries\STM32F2xx_HAL_Driver\Inc;..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\Libraries\CMSIS\Include;..\App;..\BSP\LED;..\BSP\sys;..\Middleware\FreeRTOS\include;..\Task\include;..\BSP\USART;..\BSP\NetWork;..\BSP\AHT20;..\BSP\Airquality;..\BSP\LM2904;..\BSP\PM2.5;..\BSP\OLED;..\BSP\Motor;..\BSP\SG90;..\BSP\GY906;..\BSP\Relay;..\BSP\Buzzer;..\BSP\WUHUA;..\BSP\DRV8833;..\BSP\MAX30102
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ../App/: main.c stm32f2xx_it.c freertos_demo.c
  group Task
    ../Task/: app_aht20_task.c app_air_task.c app_lm2904_task.c app_gy906_task.c app_mqttRev_task.c app_mqttSend_task.c app_max30102_task.c
  group BSP
    ../BSP/sys/: sys.c
    ../BSP/NetWork/: MqttKit.c Cloud.c cJSON.c bsp_esp8266_driver.c
    ../BSP/LED/: bsp_led_driver.c
    ../BSP/USART/: bsp_usart_driver.c
    ../BSP/AHT20/: bsp_aht20_driver.c
    ../BSP/Airquality/: bsp_airquality_driver.c
    ../BSP/LM2904/: bsp_lm2904_driver.c
    ../BSP/PM2.5/: bsp_pm2.5_driver.c
    ../BSP/OLED/: bsp_oled_driver.c oledfont.c
    ../BSP/SG90/: bsp_sg90_driver.c
    ../BSP/GY906/: bsp_gy906_driver.c
    ../BSP/Relay/: bsp_relay_driver.c
    ../BSP/Buzzer/: bsp_buzzer_driver.c
    ../BSP/WUHUA/: bsp_wuhua_driver.c
    ../BSP/DRV8833/: bsp_drv8833_driver.c
    ../BSP/MAX30102/: bsp_max30102_driver.c
  group Arm
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f205xx.s
  group FreeRTOS
    ../Middleware/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group STM32_HAL
    ../Libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_timebase_tim.c
